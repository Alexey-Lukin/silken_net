// SPDX-License-Identifier: AGPL-3.0-or-later
/*
 * logger_cycle.h — [FW.70] розклад власного циклу логера П3: коли тік WUT стає виміром.
 *
 * ⚖️ founder 2026-11-26 «(А) Власний цикл» (03_01 §12.4): після вікна консолі образ логера
 * крутить власний цикл — тік WUT ≤ 25 с (LOGCY_TICK_MAX_S) із живим псом, вимір і запис —
 * кожен N-й тік, до ключів і грошового циклу не доходить.
 *
 * Прочитання машини, не частина присуду: розклад ЧАСОВИЙ, не лічильний — вимір настає, коли
 * секунди календаря дійшли до мітки сітки каденсу; без загублених тіків і за тіку, що ділить
 * каденс, це той самий «кожен N-й тік», а загублений тік сітки не зсуває, і запізнення виміру
 * не більше за проміжок між тіками. Ціна прочитання: календар читається щотіку, і розклад
 * тримається лише доти, доки календар у межах епохи живлення не пише ніхто (⚖️ «(г) Якорі
 * зчитування» — логер його не пише).
 *
 * Контракт із журналом (logger_journal.h): сітку журналу задає перший LogJ_Record (якір BOOT),
 * тож сітка циклу народжується з ПЕРШОГО LogCy_Due, а не з LogCy_Init, — секунда, з якою Due
 * віддав вимір, і є та, що йде в LogJ_Record. Після будь-якого якоря не від циклу (запис
 * календаря в образі з маяком) — LogCy_Init знову: інакше дві сітки розійдуться на зсув
 * < каденс/4, якого журнал якорем не позначить.
 *
 * Тут лише арифметика (host-тест: make -C firmware/test logger_journal). Армінг WUT, вектор,
 * NVIC, сон і гейт циклу — glue образу на стенд-день: армінг авторюється, коли годинник плати
 * реальний (присуд 2026-06-15, 03_01 §1.10).
 *
 * Межі:
 *   · тік обмежено вікном пса: IWDG образу mini ≈ 31–35.5 с (LSI 29.5–34 кГц, 03_01 §12.4).
 *     На LSI і WUT, і пес ідуть від одного генератора, тож їхнє відношення стале; на LSE пес
 *     лишається на LSI — запас ≈ 6 с (≈ 31 − 25), якщо робота тіку коротка;
 *   · каденс ≥ 4 × тік: інакше запізнення на тік перевищує чверть каденсу, і журнал пише якір
 *     розриву на кожному записі (glue пінить це _Static_assert-ом);
 *   · годинник, що відступив за попередню мітку (у межах епохи живлення календар логера не пише
 *     ніхто), — сітку переналаштовано від поточної секунди, вимір негайно;
 *   · великий розрив (тіки губились довше за каденс) — один вимір, наступна мітка — перша
 *     після поточної секунди на СТАРІЙ сітці; пропущених вимірів не наздоганяють — розрив
 *     журнал малює сам.
 */
#ifndef SILKEN_LOGGER_CYCLE_H
#define SILKEN_LOGGER_CYCLE_H

#include <stdint.h>

#define LOGCY_TICK_MAX_S 25u

typedef struct {
    uint32_t next_s;    /* наступна мітка сітки, секунди календаря */
    uint32_t cad_s;     /* каденс, секунди; 0 — цикл вимкнено */
    uint8_t  started;   /* 0 — сітки ще немає: перший Due її народжує */
} LogCy;

static inline void LogCy_Init(LogCy *c, uint32_t cad_s)
{
    c->cad_s = cad_s;
    c->next_s = 0u;
    c->started = 0u;
}

/* 1 = на цьому тіку вимір (мітку посунуто на першу після now_s); 0 = спати далі. */
static inline int LogCy_Due(LogCy *c, uint32_t now_s)
{
    if (!c->cad_s) return 0;
    if (!c->started || (c->next_s > now_s && c->next_s - now_s > c->cad_s)) {   /* перший тік · годинник назад */
        c->started = 1u;
        c->next_s = now_s + c->cad_s;
        return 1;
    }
    if (now_s < c->next_s) return 0;
    c->next_s += ((now_s - c->next_s) / c->cad_s + 1u) * c->cad_s;
    return 1;
}

#endif /* SILKEN_LOGGER_CYCLE_H */
