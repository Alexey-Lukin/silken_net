// SPDX-License-Identifier: AGPL-3.0-or-later
/*
 * pot_dendro.h — [FW.70] потенціометричний датчик дендрометра пілота П3 (клас KTR-10: хід 10 мм,
 * доріжка 5 кΩ — присуд «П3 — склад пілота», 01_03 §4 ⊕). Чиста логіка виміру; залізо — PotDendroOps:
 * ключ збудження, затримка, сума вибірок каналу АЦП. Прошивка й host-тест компілюють цей самий код.
 *
 * Схема: верх доріжки — пін збудження (GPIO, push-pull, увімкнений лише на час виміру: 3.3 В на
 * 5 кΩ — 0.66 мА), низ — GND, повзунок — вхід АЦП «повзунок»; другий вхід АЦП «збудження» бачить
 * САМ верх доріжки (окремий провід від того самого виводу датчика).
 *
 * Показ — частка, а не напруга: сума повзунка / сума збудження × POT_DENDRO_FULL. Падіння на ключі
 * GPIO (десятки Ом на 0.66 мА — десятки мВ, ≈ 1 % шкали) і сама VDDA в частці скорочуються. Без
 * другого входу падіння ключа стало б похибкою підсилення, а його температурний хід — фальшивою
 * тепловою петлею: оцінка машини, не вимір — опір ключа гуляє на ~20 % на 40 K, тобто до ~0.2 %
 * показу, ~10 мкм посеред ходу 10 мм, а межа роздільності пілота — 5 мкм.
 *
 * Шкала показу — та сама, що журнал чекає від «12-біт АЦП × 16» (0…65520, logger_journal.h), тож
 * обидва сентинели журналу недосяжні; перерахунок у мкм — справа декодера стенда (масштаб —
 * з мікрометричної головки, не зі специфікації продавця). Порядок вибірок: половина блоку
 * збудження → увесь блок повзунка → друга половина збудження. Центри двох сум у часі збігаються,
 * тож ЛІНІЙНЕ просідання живлення за час виміру в частці скорочується без жодної зайвої вибірки.
 *
 * Межі, названі вголос:
 *   · обрив повзунка чи проводу «збудження» драйвер не бачить: вхід плаває, і показ випадковий у
 *     межах шкали — його ловить стенд «година шуму», а не цей код;
 *   · поріг збудження (¾ шкали АЦП) ловить ключ, що не тягне, закоротку верху на землю й
 *     переплутані входи «повзунок»/«збудження», поки повзунок нижче ¾ шкали АЦП (≈ ¾–⅘ ходу —
 *     залежно від того, скільки збудження доходить до верху доріжки), але не плаваючий провід;
 *   · нелінійне просідання живлення за час виміру (≈ 10 мс) не скорочується — живить AP2112 плати
 *     mini, і стенд бачить це як шум;
 *   · калібрування АЦП — справа того, хто кличе (03_01 §12.4); некалібрований зсув у кілька
 *     відліків — зсув нуля показу, його зніме масштабування головкою, а не цей код;
 *   · лінійність доріжки (продавець каже 0.5 %, паспорта виробника немає) і тепловий хід датчика
 *     прошивка не компенсує — це вимірює домашній стенд (00_07 HW.54).
 *
 * Канон: 00_07 FW.70 · 03_01 §12.4 · пін-мапа mini — 03_01, «Пін-мапа LoRa-E5 mini».
 */
#ifndef SILKEN_POT_DENDRO_H
#define SILKEN_POT_DENDRO_H

#include <stdint.h>

#define POT_DENDRO_SAMPLES   256u                        /* вибірок на канал */
#define POT_DENDRO_SETTLE_MS 2u                          /* після ключа: доріжка + RC входу, запасом */
#define POT_DENDRO_FULL      65520u                      /* = 4095 × 16 — стеля показу журналу */
#define POT_DENDRO_NONE      0xFFFFu                     /* = LOGJ_READING_NONE (пін — main.c і тест) */
#define POT_DENDRO_EXC_MIN   (POT_DENDRO_SAMPLES * 3072u) /* ¾ шкали 12-біт АЦП на вибірку */
#define POT_DENDRO_OVER_LSB  8u                          /* повзунок понад збудженням — допуск шуму */

#define POT_CH_EXCITE 0u
#define POT_CH_WIPER  1u

#define POT_OK          0
#define POT_ERR_ADC    (-1)   /* АЦП не дав суми */
#define POT_ERR_EXCITE (-2)   /* збудження нижче ¾ шкали: ключ не тягне, верх на землі — або входи
                                 «повзунок»/«збудження» переплутано, а шток не біля верху */
#define POT_ERR_RANGE  (-3)   /* повзунок вище за збудження: входи переплутано, шток біля верху */

_Static_assert((uint64_t)POT_DENDRO_SAMPLES * 4095u <= UINT32_MAX && POT_DENDRO_SAMPLES <= UINT16_MAX &&
               POT_DENDRO_SAMPLES % 2u == 0u,
               "[FW.70] сума вибірок мусить вміщатись у uint32, їх число — у n шва й ділитись навпіл");

typedef struct {
    void (*power)(void *io, int on);                                /* ключ збудження */
    void (*delay_ms)(void *io, uint32_t ms);
    int  (*adc_sum)(void *io, uint8_t ch, uint16_t n, uint32_t *sum); /* 1 = сума n вибірок каналу;
                                                                         на відмові *sum не пише */
} PotDendroOps;

typedef struct {
    int      rc;          /* POT_OK або код першого збою */
    uint16_t reading;     /* 0…POT_DENDRO_FULL; POT_DENDRO_NONE на збої */
    uint32_t exc_sum;     /* сирі суми — для стенда; 0, якщо канал не прочитано (збудження — обидві половини) */
    uint32_t wiper_sum;
} PotDendroReading;

/* Один вимір. Ключ збудження вимикається на КОЖНІЙ гілці — датчик живиться лише на час виміру. */
static inline void PotDendro_Sense(const PotDendroOps *ops, void *io, PotDendroReading *r)
{
    r->rc = POT_OK;
    r->reading = POT_DENDRO_NONE;
    r->exc_sum = 0u;
    r->wiper_sum = 0u;

    uint32_t e1 = 0u, e2 = 0u;
    ops->power(io, 1);
    ops->delay_ms(io, POT_DENDRO_SETTLE_MS);
    int ok = ops->adc_sum(io, POT_CH_EXCITE, (uint16_t)(POT_DENDRO_SAMPLES / 2u), &e1) &&
             ops->adc_sum(io, POT_CH_WIPER, (uint16_t)POT_DENDRO_SAMPLES, &r->wiper_sum) &&
             ops->adc_sum(io, POT_CH_EXCITE, (uint16_t)(POT_DENDRO_SAMPLES / 2u), &e2);
    ops->power(io, 0);

    if (!ok) { r->rc = POT_ERR_ADC; return; }   /* збудження — лише з обох половин, інакше 0 */
    r->exc_sum = e1 + e2;
    if (r->exc_sum < POT_DENDRO_EXC_MIN) { r->rc = POT_ERR_EXCITE; return; }
    if (r->wiper_sum > r->exc_sum + POT_DENDRO_SAMPLES * POT_DENDRO_OVER_LSB) {
        r->rc = POT_ERR_RANGE;
        return;
    }
    uint32_t w = (r->wiper_sum > r->exc_sum) ? r->exc_sum : r->wiper_sum;   /* шум біля верху */
    r->reading = (uint16_t)(((uint64_t)w * POT_DENDRO_FULL + r->exc_sum / 2u) / r->exc_sum);
}

#endif /* SILKEN_POT_DENDRO_H */
